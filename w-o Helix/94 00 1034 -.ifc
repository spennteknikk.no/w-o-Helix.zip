Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView], ExchangeRequirement []
File name: 2018_01
Time: 2023-06-19T11:30:39
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 22.0.10.28 - Exporter 22.0.10.28 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Jun 19 11:30:39 2023 * Host: WLOH16-009 * Database: C:\Users\AticE\AppData\Local\Temp\1a1c7ae5-2b34-403e-8dfb-3cb457cd49f9\5bf566f2-a1bf-4000-a440-577c3ebc8d80\ifc * Database version: 5507 * Database creation date: Mon Jun 19 11:30:34 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Jun 19 11:30:34 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Jun 19 11:30:34 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 2018_01
Phase: Projekt Status

# IfcSite, Default
RefLatitude: 48, 8, 15, 359802; RefLongitude: 11, 34, 47, 783432; RefElevation: 519 m
Sonstige - Auftraggeber: Bauherr; Kategorie: Projektinformationen; Projektadresse: Projektadresse; Projektausgabedatum: Projekt Datum; Projektnummer: 2018_01; Projektstatus: Projekt Status; Verfasser eMail: E-Mail; Verfasser Firma 1: AUTODESK GmbH; Verfasser PLZ Ort: Ort; Verfasser Strasse: Adresse; Verfasser Telefon: Telefon; Verfasser URL: www.Autodesk.de/BIM
Text - Bauherr: AUTODESK; Baustellenort: BAUORT; Baustellenstraße: BAUSTRASSE 1; Einlagezahl: 123-45; Gerichtsbezirk: GERICHTSBEZIRK; Grundstücksnummer: GR; Katastralgemeinde: KG; Kundenadresse: KUNDENSTRASSE 1; Kundenort: KUNDENORT; Kundentelefon: 0000-00000-1; Kundenzusatz: KUNDENZUSATZ

# IfcBuildingElementProxy: Familie1:Norm, Familie1:Norm:2412780
In: Default
Type - Material: Schnee
Type - Abhängigkeiten - Vorgabe-Ansicht: 0 m
Type - ID-Daten - Typname: Norm
Type - Sonstige - Kategorie: Allgemeines Modell; Familienname: Familie1
Pset_BuildingElementProxyCommon - Reference: Norm; sets with these values: 2
Abhängigkeiten - Basisbauteil: Keine; Höhe von Ebene: 0 m; Versatz von Host: 0 m; Verschieben mit umliegenden Elementen: no
Bemaßungen - Fläche: 0.426866 m2; Volumen: 0.0038512 m3
Phasen - Phase erstellt: Phase 2
Sonstige - Familie: Familie1: Norm; Familie und Typ: Familie1: Norm; Typ: Familie1: Norm; Typ-ID: Familie1: Norm
